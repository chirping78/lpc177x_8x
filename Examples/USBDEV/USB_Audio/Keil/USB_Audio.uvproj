# Keil uVision project USB_Audio.uvproj, settings and files
target Flash (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: usbaudio +hex
  c flags: Optim=1
  c include: ..;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC177x_8x\Include;..\..\..\..\Drivers\include
  asm include: ..\Common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\FLASH_DMA.sct
  group Startup
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/ARM/: startup_LPC177x_8x.s
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Drivers
    ../../../../Drivers/source/: lpc177x_8x_clkpwr.c lpc177x_8x_adc.c lpc177x_8x_dac.c lpc177x_8x_gpio.c lpc177x_8x_pinsel.c lpc177x_8x_timer.c debug_frmwrk.c lpc177x_8x_uart.c
  group Main
    ../: adcuser.c usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.c
  group ReadMe
    ../: abstract.txt
target Ram (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: usbaudio +hex
  c flags: Optim=1
  c define: __RAM_MODE__
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC177x_8x\Include;..\..\..\..\Drivers\include;..;..\..\..\..\BoardSupport
  asm define: NO_CRP
  asm include: ..\Common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\RAM_DMA.sct
