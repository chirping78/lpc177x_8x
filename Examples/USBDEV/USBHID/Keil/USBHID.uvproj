# Keil uVision project USBHID.uvproj, settings and files
target RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: USBHID
  c flags: Optim=3
  c include: ..\common\inc
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup Code
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/ARM/: startup_LPC177x_8x.s
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Main
    ../: demo.c hiduser.c usbcore.c usbdesc.c usbuser.c usbhw.c
  group Readme
    ../: Abstract.txt
  group Driver
    ../../../../BoardSupport/: pca9532.c
    ../../../../Drivers/source/: lpc177x_8x_i2c.c lpc177x_8x_clkpwr.c lpc177x_8x_pinsel.c lpc177x_8x_gpio.c lpc177x_8x_timer.c
target FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: USBHID +hex
  c flags: Optim=1
  c include: ..;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC177x_8x\Include;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport
  asm define: NO_CRP
  asm include: ..\common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
