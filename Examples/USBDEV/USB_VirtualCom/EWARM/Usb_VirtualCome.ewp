# IAR project Usb_VirtualCome.ewp, settings and files
configuration Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCDefines: NOT_USING_TEST_CHIP
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Core\CM3\CoreSupport; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC178x; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC178x\startup\iar; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Adc_Dma.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC178x\linker\ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS-CM3
    ../../../../Core/CM3/CoreSupport/: core_cm3.c
    ../../../../Core/CM3/DeviceSupport/NXP/LPC178x/: system_LPC178x.c
  group Main
    ../: cdcuser.c serial.c usbcore.c usbdesc.c usbhw.c usbuser.c vcomdemo.c
  group Readme
    ../: abstract.txt
  group Startup
    ../../../../Core/CM3/DeviceSupport/NXP/LPC178x/startup/iar/: startup_LPC178x.s
