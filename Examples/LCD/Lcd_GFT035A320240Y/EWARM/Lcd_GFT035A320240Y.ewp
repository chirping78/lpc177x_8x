# IAR project Lcd_GFT035A320240Y.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe068, Pe550, Pe186, Pa039, Pe144, Pe128, Pe177
  ICCARM.CCIncludePath2: ..\app; ..\modules; ..\board; ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\LPC177x_8x\Include; ..\..\..\..\Core\Device\NXP\LPC177x_8x\Source\Templates\IAR; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lcd_GFT035A320240Y.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\Core\Device\NXP\LPC177x_8x\Source\Templates\linker\ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../app/: Cursor.c main.c NXP_logo_16.c NXP_logo_2.c NXP_logo_24.c
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Drivers
    ../../../../Drivers/source/: lpc177x_8x_adc.c lpc177x_8x_clkpwr.c lpc177x_8x_i2c.c lpc177x_8x_lcd.c lpc177x_8x_pinsel.c lpc177x_8x_pwm.c
    ../../../../BoardSupport/: sdram_k4s561632j.c sensor_smb380.c
  group Readme
    ../: abstract.txt
  group Startup
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/IAR/: startup_LPC177x_8x.s
