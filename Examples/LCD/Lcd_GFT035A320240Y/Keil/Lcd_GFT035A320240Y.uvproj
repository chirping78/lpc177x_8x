# Keil uVision project Lcd_GFT035A320240Y.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Lcd_GFT035A320240Y +hex
  c flags: Optim=1 wLevel=1
  c include: ..\board;..\app;..\config;..\modules;..\..\..\..\Drivers\include;..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x;..\..\..\..\BoardSupport
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ../../../../Core/CM3/DeviceSupport/NXP/LPC177x_8x/startup/arm/: startup_LPC177x_8x.s
  group CMSIS-CM3
    ../../../../Core/CM3/CoreSupport/: core_cm3.c
    ../../../../Core/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
  group Main
    ../app/: main.c
  group Readme
    ../: abstract.txt
  group App
    ../app/: Cursor.c logo.c
  group Drivers
    ../modules/: drv_glcd.c smb380_drv.c i2c1_drv.c
    ../../../../Drivers/source/: lpc177x_8x_clkpwr.c
    ../../../../BoardSupport/: sdram_k4s561632j.c
