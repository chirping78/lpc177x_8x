# IAR project Emc_Yaffs.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  ICCARM.CCIncludePath2: ..; ..\yaffs2\; ..\yaffs2\direct; ..\yaffs2\direct\basic-test; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\LPC177x_8x\Include; ..\..\..\..\Core\Device\NXP\LPC177x_8x\Source\Templates\IAR; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Adc_Dma.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_emc.c lpc177x_8x_pinsel.c lpc177x_8x_timer.c lpc177x_8x_uart.c
    ../../../../BoardSupport/: nandflash_k9f1g08u0a.c sdram_is42s32800d.c
  group Main
    ../: yaffs_demo.c
  group Readme
    ../: abstract.txt
  group Startup
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/IAR/: startup_LPC177x_8x.s
  group Yaffs
    ../yaffs2/: yaffs_allocator.c yaffs_bitmap.c yaffs_checkptrw.c yaffs_ecc.c yaffs_guts.c yaffs_nameval.c yaffs_nand.c yaffs_packedtags2.c yaffs_qsort.c yaffs_tagscompat.c yaffs_tagsvalidity.c yaffs_verify.c yaffs_yaffs1.c yaffs_yaffs2.c
    ../yaffs2/direct/: yaffs_nandif.c yaffsfs.c
    ../yaffs2/direct/basic-test/: yaffsnewcfg.c ynandsim.c
