# Keil uVision project Emc_Yaffs.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Emc_Yaffs +hex
  c flags: Optim=1 wLevel=1
  c include: ..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC177x_8x\Include;..\yaffs2\direct\basic-test;..\yaffs2\direct;..\yaffs2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Emc_Yaffs.sct
  group Startup
    ./: startup_LPC177x_8x.s
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Drivers
    ../../../../Drivers/source/: lpc177x_8x_pinsel.c debug_frmwrk.c lpc177x_8x_uart.c lpc177x_8x_clkpwr.c lpc177x_8x_crc.c lpc177x_8x_emc.c lpc177x_8x_timer.c
    ../../../../BoardSupport/: nandflash_k9f1g08u0a.c sdram_is42s32800d.c
  group Yaffs
    ../yaffs2/direct/: yaffsfs.c yaffs_nandif.c
    ../yaffs2/: yaffs_guts.c yaffs_nand.c yaffs_tagsvalidity.c yaffs_checkptrw.c yaffs_qsort.c yaffs_tagscompat.c yaffs_ecc.c yaffs_packedtags2.c yaffs_verify.c yaffs_yaffs1.c yaffs_yaffs2.c yaffs_allocator.c yaffs_nameval.c yaffs_bitmap.c
    ../yaffs2/direct/basic-test/: yaffsnewcfg.c ynandsim.c
  group Main
    ../: yaffs_demo.c
  group Readme
    ../: abstract.txt
