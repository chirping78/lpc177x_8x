# Keil uVision project Rtc_Calibration.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Rtc_Calibration +hex
  c flags: Optim=1 wLevel=1
  c include: ..\..\..\..\Core\CM3\CoreSupport;..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x;..\..\..\..\Drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ../../../../Core/CM3/DeviceSupport/NXP/LPC177x_8x/startup/arm/: startup_LPC177x_8x.s
  group CMSIS-CM3
    ../../../../Core/CM3/CoreSupport/: core_cm3.c
    ../../../../Core/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_gpdma.c lpc177x_8x_pinsel.c lpc177x_8x_uart.c lpc177x_8x_rtc.c
  group Main
    ../: Rtc_Calibration.c
  group Readme
    ../: abstract.txt
target RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: Rtc_Calibration
  c flags: Optim=1 wLevel=1
  c define: __RAM_MODE__
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
