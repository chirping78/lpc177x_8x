# Keil uVision project Can_SimpleTxRx.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Can_SimpleTxRx +hex
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC177x_8x\Include;..\..\..\..\Drivers\include;..\..\Can_Bypass
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/ARM/: startup_LPC177x_8x.s
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_pinsel.c lpc177x_8x_can.c lpc177x_8x_uart.c lpc177x_8x_exti.c
  group Main
    ../: Can_SimpleTxRx.c
  group Readme
    ../: abstract.txt
target RAM (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: Can_SimpleTxRx +hex
  c flags: Optim=1 wLevel=2
  c define: __RAM_MODE__
  c include: ..\..\..\..\Drivers\include;..\..\Can_Bypass;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC177x_8x\Include
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
