# Keil uVision project I2c_Pca9532Drv.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: I2c_Pca9532Drv +hex
  c flags: Optim=1 wLevel=1
  c include: ..\..\..\..\Core\CM3\CoreSupport;..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x;..\..\..\..\Drivers\include;..\..\I2c_Pca9532Drv;..\..\..\..\BoardSupport
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ../../../../Core/CM3/DeviceSupport/NXP/LPC177x_8x/startup/arm/: startup_LPC177x_8x.s
  group CMSIS-CM3
    ../../../../Core/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
    ../../../../Core/CM3/CoreSupport/: core_cm3.c
  group Drivers
    ../../../../Drivers/source/: lpc177x_8x_i2c.c lpc177x_8x_pinsel.c lpc177x_8x_clkpwr.c
  group Main
    ../: I2c_Pca9532Drv.c
  group Readme
    ../: abstract.txt
  group BoardSupport
    ../../../../BoardSupport/: pca9532.c
target RAM (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: I2c_Pca9532Drv
  c flags: Optim=1 wLevel=1
  c define: __RAM_MODE__
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0xc000
  memory RVCT10: RAM 0x20000000 size 0x8000
