# IAR project UsbHost_MassStorage.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\LPC177x_8x\Include; ..\..\..\..\Core\Device\NXP\LPC177x_8x\Source\Templates\IAR; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UsbHost_MassStorage.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\Core\Device\NXP\LPC177x_8x\Source\Templates\linker\ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __RAM_MODE__
  ILINK.IlinkIcfFile: ..\..\..\..\Core\Device\NXP\LPC177x_8x\Source\Templates\linker\ldscript_iram_iar.icf
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_pinsel.c lpc177x_8x_uart.c lpc177x_8x_usbhost.c
  group Main
    ../: usbhost_main.c
  group MassStorage
    ../: usbhost_ms.c
  group ReadMe
    ../: abstract.txt
  group Startup
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/IAR/: startup_LPC177x_8x.s
  group Utilities
    ../: usbhost_fat.c usbhost_uart.c
