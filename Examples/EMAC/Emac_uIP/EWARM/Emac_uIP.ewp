# IAR project Emac_uIP.ewp, settings and files
configuration Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe068, Pe550, Pe186, Pa039, Pe144, Pe128, Pe177
  ICCARM.CCIncludePath2: ..\apps\webserver; ..\lpc177x_8x_port; ..\uIP; ..; ..\..\..\..\Core\CM3\CoreSupport; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x\startup\iar; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: UART.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x\linker\ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS-CM3
    ../../../../Core/CM3/CoreSupport/: core_cm3.c
    ../../../../Core/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
  group Common
    ../common/: printf-stdarg.c Serial.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_emac.c lpc177x_8x_pinsel.c lpc177x_8x_uart.c
  group Port
    ../lpc177x_8x_port/: clock-arch.c emac.c Emac_uIP.c
  group Readme
    ../: abstract.txt
  group Startup
    ../../../../Core/CM3/DeviceSupport/NXP/LPC177x_8x/startup/iar/: startup_LPC177x_8x.s
  group uIP
    ../uip/: psock.c timer.c uip.c uip_arp.c
  group Webserver
    ../apps/webserver/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
