# Keil uVision project Emac_InternetRadio.uvproj, settings and files
target Flash (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Emac_WebRadio +hex
  c flags: Optim=1 wLevel=2
  c define: DNS_USED,
  c include: ..\apps\webclient;..\lpc177x_8x_port;..\uip;..\apps;..\apps\resolv;..\common;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC177x_8x\Include;..\apps\dhcpc;..\lib\mp3codec;..\lib\mp3codec\pub
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Core Files
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/ARM/: startup_LPC177x_8x.s
  group Driver Files
    ../../../../Drivers/source/: debug_frmwrk.c lpc177x_8x_uart.c lpc177x_8x_clkpwr.c lpc177x_8x_emac.c lpc177x_8x_pinsel.c lpc177x_8x_gpio.c lpc177x_8x_i2c.c lpc177x_8x_i2s.c lpc177x_8x_gpdma.c lpc177x_8x_emc.c lpc177x_8x_timer.c
    ../../../../BoardSupport/: phylan.c uda1380.c sdram_is42s32800d.c sdram_k4s561632j.c sdram_mt48lc8m32lfb5.c
  group port
    ../lpc177x_8x_port/: clock-arch.c emac.c Emac_uIP.c decoder.c
  group Common
    ../common/: Serial.c
  group uIP
    ../uip/: uiplib.c uip_arp.c psock.c timer.c uip.c
  group mp3
    ../lpc177x_8x_port/asm/ARM/: asmmisc.s asmpoly.s
    ../lib/mp3codec/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c scalfact.c stproc.c subband.c trigtabs.c
  group DHCP
    ../apps/dhcpc/: dhcpc.c
  group DNS
    ../apps/resolv/: resolv.c
  group WebClient
    ../apps/webclient/: webclient.c webclient-strings.c
  group Readme
    ../: abstract.txt
