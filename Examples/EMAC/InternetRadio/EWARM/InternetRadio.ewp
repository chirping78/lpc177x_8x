# IAR project InternetRadio.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DHCP_ENABLE
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe068, Pe550, Pe186, Pa039, Pe144, Pe128, Pe177
  ICCARM.CCIncludePath2: ..\apps\webclient; ..\apps\webbrowser; ..\apps\resolv; ..\apps\dhcpc; ..\lpc177x_8x_port; ..\uIP; ..\lib\mp3codec; ..\lib\mp3codec\pub; ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\LPC177x_8x\Include; ..\..\..\..\Core\Device\NXP\LPC177x_8x\Source\Templates\IAR; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UART.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\makesection\makerule\linker\ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Common
    ../../../../BoardSupport/: phylan.c
    ../common/: printf-stdarg.c Serial.c
  group DHCP
    ../apps/dhcpc/: dhcpc.c
  group DNS
    ../apps/resolv/: resolv.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_emac.c lpc177x_8x_emc.c lpc177x_8x_gpdma.c lpc177x_8x_i2c.c lpc177x_8x_i2s.c lpc177x_8x_pinsel.c lpc177x_8x_timer.c lpc177x_8x_uart.c
    ../../../../BoardSupport/: sdram_is42s32800d.c sdram_k4s561632j.c sdram_mt48lc8m32lfb5.c uda1380.c
  group Mp3
    ../lpc177x_8x_port/asm/IAR/: asmmisc.s asmpoly.s
    ../lib/mp3codec/: assembly.h bitstream.c buffers.c coder.h dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c scalfact.c stproc.c subband.c trigtabs.c
  group Port
    ../lpc177x_8x_port/: clock-arch.c decoder.c emac.c Emac_uIP.c
  group Readme
    ../: abstract.txt
  group Startup
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/IAR/: startup_LPC177x_8x.s
  group uIP
    ../uip/: psock.c timer.c uip.c uip_arp.c uiplib.c
  group WebClient
    ../apps/webbrowser/: html-strings.c htmlparser.c
    ../apps/webclient/: webclient-strings.c webclient.c
