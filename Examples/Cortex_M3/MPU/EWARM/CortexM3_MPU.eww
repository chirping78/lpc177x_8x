<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CortexM3_MPU.ewp</path>
  </project>
  <batchBuild/>
</workspace>


